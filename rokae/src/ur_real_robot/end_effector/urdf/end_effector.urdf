Commit message: Synchronization

File: rokae/src/ur_real_robot/end_effector/urdf/end_effector.urdf (robot description, URDF)
Before this commit: robot end_effector, 1 links, 0 joints
Links:
- link pneumatic_base_link: mass 0.77161 -> 0.79203
